# Keil uVision project Car_1.uvprojx, settings and files
target Car_1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: Flight +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: --no-multibyte-chars
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;./FreeRTOS;./FreeRTOS/include;./FreeRTOS/portable;./application;./interface;./common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: OLED.c OLED_Data.c main.c gpio.c can.c i2c.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_can.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group FreeRTOS
    ./FreeRTOS/: croutine.c event_groups.c FreeRTOSConfig.h list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/include
    ./FreeRTOS/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group FreeRTOS/portable
    ./FreeRTOS/portable/: heap_4.c port.c portmacro.h
  group applicstion
    ./Application/: FreeRTOS_Task.c
    ./application/: App_Types.h FreeRTOS_Task.h
  group interface
    ./interface/: BlueTooth.c Engine.c LED.c Motor.c PWM.c HCSR04.c MPU6050.c Flash.c MyCAN.c
  group common
    ./common/: Bluetooth_data.c Bluetooth_data.h Motor_PID.c Motor_PID.h mode_control.c mode_control.h Record_Play_Task.c Record_Play_Task.h Bow_Path_Task.c Bow_Path_Task.h MPU6050_data.c MPU6050_data.h OLED_Show_Task.c OLED_Show_Task.h Avoidance_Task.c Avoidance_Task.h Host_CAN_App.c Host_CAN_App.h Odometry.c Odometry.h Vacuum.c Vacuum.h System_Config.c System_Config.h
software components: CMSIS:CORE 4.3.0
